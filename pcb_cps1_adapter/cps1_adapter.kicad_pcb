# Repository marqs85/cps2_digiav

File README.md:

CPS2 digital AV interface (Rev 2)
==============

Overview
--------------------------
cps2_digiav is an add-on for Capcom CP System II and some other arcade boards. It enables digital video and audio output via HDMI connector. The project consists of a common interface PCB (`pcb/`) and board-specific FPGA firmware (`board/<board>/output_files/cps2_digiav.jic`).

Supported boards
--------------------------
* CPS1 (89626A)
* CPS2
* CPS3
* Neo Geo (MV1C, AES3-3 and AES3-6, possibly others as well)
* Toaplan V2

Hardware
--------------------------
The add-on [PCB](https://oshpark.com/shared_projects/fxG9hou9) design can be self-built or bought [pre-assembled](https://videogameperfection.com/products/cps2-cps3-digital-av-interface-diy-kit/).

* Installation typically requires a small number of additional components which are listed in board-specific READMEs.

More info and discussion
--------------------------
* [Forum topic](http://shmups.system11.org/viewtopic.php?f=6&t=59479&p=1266977)

## KiCad design pcb_cps1_adapter/cps1_adapter.kicad_pcb

Parts:
C1, C3, C5, C8, C10: 10u; SM0603_Capa_libcms
C2, C4, C6, C7, C9, C11: 0.1u; SM0603_Capa_libcms
J1, J2, J3, J4, J5: Conn_02x05_Counter_Clockwise; HLE-105-02-G-DV-PE
R1, R5: 1.8k; SM0603_Resistor_libcms
R2, R3, R6: 3.3k; SM0603_Resistor_libcms
R4: 1M; SM0603_Resistor_libcms
TP1, TP8: GND; SMD_PAD
TP2: DAO; SMD_PAD
TP3: 3v3; SMD_PAD
TP4: SO; SMD_PAD
TP5: YM_SO; SMD_PAD
TP6: YM_oC1; SMD_PAD
TP7: YM_SH1; SMD_PAD
TP9: YM_oCM; SMD_PAD
TP10: I2S_BCK_o; SMD_PAD
TP11: I2S_DATA_o; SMD_PAD
TP12: I2S_WS_o; SMD_PAD
TP13: QS_BCK; SMD_PAD
TP14: QS_DAT; SMD_PAD
TP15: QS_WS; SMD_PAD
TP16: QS_SEL; SMD_PAD
U1, U2: (no value)
U3: 74LVC157; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
/B0: J1.2, J4.2
/B1: J1.3, J4.3
/B2: J1.4, J4.4
/B3: J1.6, J4.6
/DAO: C8.1, TP2.1
/DVDD3V3: C1.1, C2.1, C6.1, C9.1, R3.2, TP3.1, U1.2 (1K), U1.3 (1J), U1.4 (1PRE), U1.10 (2PRE), U1.15 (1CLR), U1.16 (Vcc), U2.5 (DVDD), U3.16 (VCC)
/DVDD5V: C10.1, C11.1, J3.10, U2.13 (AVDD)
/F0: J2.7, J5.7
/F1: J2.8, J5.8
/F2: J2.9, J5.9
/F3: J2.10, J5.10
/G0: J1.7, J4.7
/G1: J1.8, J4.8
/G2: J1.9, J4.9
/G3: J1.10, J4.10
/LRCLK: U1.5 (1Q), U2.3 (LRCLK)
/QS_BCK: TP13.1, U3.2 (I0a)
/QS_DAT: TP14.1, U3.5 (I0b)
/QS_WS: TP15.1, U3.11 (I0c)
/R0: J2.2, J5.2
/R1: J2.3, J5.3
/R2: J2.4, J5.4
/R3: J2.6, J5.6
/SO: TP4.1, U2.2 (DOUT)
/VMID: C3.1, C4.1, R4.1, U2.10 (VMID)
/YM_SH1: TP7.1, U1.1 (1CLK), U3.10 (I1c)
/YM_SO: TP5.1, U3.6 (I1b)
/YM_oC1: R5.1, TP6.1, U3.3 (I1a)
/YM_oCM: R1.1, TP9.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, J1.5, J2.5, J4.5, J5.5, R2.2, R6.2, TP1.1, TP8.1, U1.8 (GND), U1.11 (2J), U1.12 (2K), U1.13 (2CLK), U1.14 (2CLR), U2.4 (DGND), U2.8 (FSAMPEN), U2.11 (VREFGND), U2.14 (AGND), U2.20 (M/S), U3.8 (GND), U3.13 (I1d), U3.14 (I0d), U3.15 (E)
unnamed: C5.1, C7.1, U2.12 (VREFP)
unnamed: C8.2, R4.2, U2.17 (COM)
unnamed: R1.2, R2.1, U2.1 (MCLK)
unnamed: R3.1, TP16.1, U3.1 (S)
unnamed: R5.2, R6.1, U2.6 (BCLK)
unnamed: TP10.1, U3.4 (Za)
unnamed: TP11.1, U3.7 (Zb)
unnamed: TP12.1, U3.9 (Zc)
unnamed: U2.15 (AINOPR), U2.16 (AINR)
unnamed: U2.18 (AINOPL), U2.19 (AINL)

Board: 2 copper layers, 70.1 x 63.5 mm, 41 parts (0 on the bottom side), 40 nets.

## KiCad design pcb_neogeo_aadc/neogeo_aadc.kicad_pcb

Board: 2 copper layers, 33.4 x 10.9 mm, 30 parts (0 on the bottom side), 20 nets.

Parts:
C1, C2, C5, C7, C8, C9: 10u; SM0603_Capa_libcms
C3, C4, C6, C10: 0.1u; SM0603_Capa_libcms
C11, C12: 1u; SM0603_Capa_libcms
R1: 10k; SM0603_Resistor_libcms
R2, R3, R4, R5: 5k; SM0603_Resistor_libcms
R6: 3.3k; SM0603_Resistor_libcms
TP1: 5V; SMD_PAD
TP2, TP7: GND; SMD_PAD
TP3: MCLK; SMD_PAD
TP4: DATA; SMD_PAD
TP5: WS; SMD_PAD
TP6: BCK; SMD_PAD
TP8: AINL; SMD_PAD
TP9: AINR; SMD_PAD
U1: 74LVC1G17; SOT-23-5_HandSoldering
U2: WM8782; TSSOP-20_4.4x6.5mm_Pitch0.65mm_Handsoldering
U3: TLV70033_SOT23-5; SOT-23-5_HandSoldering

Connections:
/DVDD5: C9.1, C10.1, C11.1, TP1.1, U2.13, U3.1, U3.3
/VMID: C2.1, C4.1, R6.1, U2.10
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C12.2, TP2.1, TP7.1, U1.3, U2.4, U2.7, U2.8, U2.9, U2.11, U2.14, U3.2
unnamed: C5.1, C6.1, U2.12
unnamed: C7.1, TP8.1
unnamed: C7.2, R4.1
unnamed: C8.1, TP9.1
unnamed: C8.2, R5.1
unnamed: R1.2, U2.20
unnamed: R2.1, R4.2, U2.19
unnamed: R2.2, U2.18
unnamed: R3.1, R5.2, U2.16
unnamed: R3.2, U2.15
unnamed: R6.2, U2.17
unnamed: TP3.1, U1.2
unnamed: TP4.1, U2.2
unnamed: TP5.1, U2.3
unnamed: TP6.1, U2.6
unnamed: U1.4, U2.1
VCC: C1.1, C3.1, C12.1, R1.1, U1.5, U2.5, U3.5

## KiCad design pcb/cps2_digiav.kicad_pcb

Schematic: cps2_digiav.sch

Parts:
C1, C3: 10u; SM0603_Capa_libcms
U7: AP7361; SOT-223_Handsoldering

Connections:
/5V: C1.1, U7.1; also elsewhere on the board
/hdmitx1/DVDD3V3: C3.1, U7.3; also elsewhere on the board
GND: C1.2, C3.2, U7.2; also elsewhere on the board

Notes on the sheet:
max. 184mA drawn
I2C pull-ups inside
max. 273mA drawn
max. 500mA
max. 100mA drawn

Schematic: hdmitx.sch, CPS2_digiAV

Parts:
C10, C11, C12, C13: 10u; SM0603_Capa_libcms
C69, C73, C74, C75, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86: 0.1u; SM0603_Capa_libcms
C87, C89: 1u; SM0603_Capa_libcms
D2, D3: RClamp0524P; SLP2510P8
D4: ZHCS400TA; SOD-323_Handsoldering
F2: MF-FSMF020X-2; SM0603_Resistor_libcms
FB1, FB2, FB3, FB4: MPZ1608S221A; SM0603_Resistor_libcms
J4: HDMI_CONN; HDMI_CONN-10029449-111RLF; Part ID 10029449-111RLF
R3: 887; SM0603_Resistor_libcms
R5, R45, R46: 2.2k; SM0603_Resistor_libcms
R41: 10k; SM0603_Resistor_libcms
U1: ADV7513; LQFP-64-1EP_10x10mm_Pitch0.5mm_Handsoldering
U15: TLV70018; SOT-23-5_Handsoldering

Connections:
/5V: D4.2; also elsewhere on the board
/fpga1/HDMITX_HSYNC: U1.64 (HSYNC); also elsewhere on the board
/fpga1/HDMITX_I2S_BCK: U1.9 (SCLK); also elsewhere on the board
/fpga1/HDMITX_I2S_DATA: U1.5 (I2S0); also elsewhere on the board
/fpga1/HDMITX_I2S_WS: U1.10 (LRCLK); also elsewhere on the board
/fpga1/HDMITX_INT_N: R5.2, U1.28 (INT); also elsewhere on the board
/fpga1/HDMITX_PCLK: U1.53 (CLK); also elsewhere on the board
/fpga1/HDMITX_R0: U1.44 (DATA16); also elsewhere on the board
/fpga1/HDMITX_R1: U1.43 (DATA17); also elsewhere on the board
/fpga1/HDMITX_R2: U1.42 (DATA18); also elsewhere on the board
/fpga1/HDMITX_R3: U1.41 (DATA19); also elsewhere on the board
/fpga1/HDMITX_R4: U1.40 (DATA20); also elsewhere on the board
/fpga1/HDMITX_R5: U1.39 (DATA21); also elsewhere on the board
/fpga1/HDMITX_R6: U1.38 (DATA22); also elsewhere on the board
/fpga1/HDMITX_R7: U1.37 (DATA23); also elsewhere on the board
/fpga1/HDMITX_VSYNC: U1.2 (VSYNC); also elsewhere on the board
/fpga1/SCL: U1.35 (SCL); also elsewhere on the board
/fpga1/SDA: U1.36 (SDA); also elsewhere on the board
/hdmitx1/5V_FUSED: F2.2, J4.18 (+5V), R45.1, R46.1
/hdmitx1/B0: U1.62 (DATA0); also elsewhere on the board
/hdmitx1/B1: U1.61 (DATA1); also elsewhere on the board
/hdmitx1/B2: U1.60 (DATA2); also elsewhere on the board
/hdmitx1/B3: U1.59 (DATA3); also elsewhere on the board
/hdmitx1/B4: U1.58 (DATA4); also elsewhere on the board
/hdmitx1/B5: U1.57 (DATA5); also elsewhere on the board
/hdmitx1/B6: U1.56 (DATA6); also elsewhere on the board
/hdmitx1/B7: U1.55 (DATA7); also elsewhere on the board
/hdmitx1/DDCSCL: J4.15 (SCL), R46.2, U1.33 (DDCSCL)
/hdmitx1/DDCSDA: J4.16 (SDA), R45.2, U1.34 (DDCSDA)
/hdmitx1/DE: U1.63 (DE); also elsewhere on the board
/hdmitx1/DVDD1V8: C74.1, C85.1, C86.1, C89.1, FB1.1, FB2.1, FB3.2, U15.5
/hdmitx1/DVDD1V8_FILT_AVDD: C13.1, C79.1, C83.1, C84.1, FB1.2, U1.15 (AVDD), U1.19 (AVDD), U1.25 (AVDD)
/hdmitx1/DVDD1V8_FILT_DVDD: C10.1, C77.1, C78.1, C80.1, C81.1, FB3.1, U1.1 (DVDD), U1.11 (DVDD), U1.31 (DVDD), U1.51 (DVDD)
/hdmitx1/DVDD1V8_FILT_PVDD: C12.1, C69.1, C73.1, FB2.2, U1.12 (PVDD), U1.13 (BGVDD)
/hdmitx1/DVDD3V3: C75.1, C87.1, FB4.2, U15.1, U15.3; also elsewhere on the board
/hdmitx1/DVDD3V3_FILT_DVDD_3V: C11.1, C82.1, FB4.1, R5.1, U1.29 (DVDD_3V)
/hdmitx1/G0: U1.54 (DATA8); also elsewhere on the board
/hdmitx1/G1: U1.52 (DATA9); also elsewhere on the board
/hdmitx1/G2: U1.50 (DATA10); also elsewhere on the board
/hdmitx1/G3: U1.49 (DATA11); also elsewhere on the board
/hdmitx1/G4: U1.48 (DATA12); also elsewhere on the board
/hdmitx1/G5: U1.47 (DATA13); also elsewhere on the board
/hdmitx1/G6: U1.46 (DATA14); also elsewhere on the board
/hdmitx1/G7: U1.45 (DATA15); also elsewhere on the board
/hdmitx1/HPD: J4.19 (HPD), R41.1, U1.16 (HPD)
/hdmitx1/TX0+: D3.1, D3.10, J4.7 (TMDS_D0+), U1.21 (TX0+)
/hdmitx1/TX0-: D3.2, D3.9, J4.9 (TMDS_D0-), U1.20 (TX0-)
/hdmitx1/TX1+: D2.4, D2.7, J4.4 (TMDS_D1+), U1.24 (TX1+)
/hdmitx1/TX1-: D2.5, D2.6, J4.6 (TMDS_D1-), U1.23 (TX1-)
/hdmitx1/TX2+: D2.1, D2.10, J4.1 (TMDS_D2+), U1.27 (TX2+)
/hdmitx1/TX2-: D2.2, D2.9, J4.3 (TMDS_D2-), U1.26 (TX2-)
/hdmitx1/TXC+: D3.4, D3.7, J4.10 (TMDS_CLK+), U1.18 (TXC+)
/hdmitx1/TXC-: D3.5, D3.6, J4.12 (TMDS_CLK-), U1.17 (TXC-)
GND: C10.2, C11.2, C12.2, C13.2, C69.2, C73.2, C74.2, C75.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C89.2, D2.3, D2.8, D3.3, D3.8, J4.2 (TMDS_D2_GND), J4.5 (TMDS_D1_GND), J4.8 (TMDS_D0_GND), J4.11 (TMDS_CLK_GND), J4.17 (DDC_GND), R3.2, R41.2, U1.3 (SPDIF), U1.4 (MCLK), U1.6 (I2S1), U1.7 (I2S2), U1.8 (I2S3), U1.22 (PD), U1.32 (CEC_CLK), U1.65 (PAD/GND), U15.2; also elsewhere on the board
unnamed: D4.1, F2.1
unnamed: R3.1, U1.14 (R_EXT)

Notes on the sheet:
max. 55mA
max. 200mA
max. 1mA (OVDD)
max. 1mA (AVCC33)
max. 55mA (AVCC18)
max. 127mA (DVDD18)

Schematic: input1.sch, CPS2_digiAV

Parts:
C2, C6, C7, C8, C9, C14, C15, C16: 0.1u; SM0603_Capa_libcms
C5: 47u; SM0603_Capa_libcms
D1: SD05-7; SOD-323_Handsoldering
J1, J2: Conn_02x05; HLE-105-02-G-DV-PE
R4: 4.7k; SM0603_Resistor_libcms
R7, R8: 10k; SM0603_Resistor_libcms
SW1: TL2243
U3, U4, U5: 74LVC245; TSSOP-20_4.4x6.5mm_Pitch0.65mm_Handsoldering
U6: SI5351C-B; QFN-20-1EP_4x4mm_Pitch0.5mm_Handsoldering
U8, U9, U16: SN74LVC2G17; SOT-23-6_Handsoldering
W1: 5V; SMD_PAD
W2: BCK; SMD_PAD
W3: WS; SMD_PAD
W4: DAT; SMD_PAD
W5: vol+; SMD_PAD
W6: vol-; SMD_PAD
W7, W8, W9, W10, W14: GND; SMD_PAD
W11: HS; SMD_PAD
W12: VS; SMD_PAD
W13: C2; SMD_PAD
W15: C1; SMD_PAD

Connections:
/5V: C5.1, D1.1, W1.1; also elsewhere on the board
/fpga1/I2S_BCK: U8.4; also elsewhere on the board
/fpga1/I2S_DATA: U5.16 (B2); also elsewhere on the board
/fpga1/I2S_WS: U5.13 (B5); also elsewhere on the board
/fpga1/MCLK_SI: U6.16; also elsewhere on the board
/fpga1/PCLK_SI: U6.12; also elsewhere on the board
/fpga1/SCL: U6.4; also elsewhere on the board
/fpga1/SDA: U6.5; also elsewhere on the board
/hdmitx1/DVDD3V3: C2.1, C6.2, C7.2, C8.2, C9.2, C14.1, C15.2, C16.2, R4.1, R7.1, R8.1, U3.1 (A->B), U3.20 (VCC), U4.1 (A->B), U4.20 (VCC), U5.1 (A->B), U5.20 (VCC), U6.10, U6.11, U6.14, U6.18, U6.20, U8.5, U9.5, U16.5; also elsewhere on the board
/input1/B0: J1.2, U4.4 (A2)
/input1/B0_O: U4.16 (B2); also elsewhere on the board
/input1/B1: J1.3, U4.3 (A1)
/input1/B1_O: U4.17 (B1); also elsewhere on the board
/input1/B2: J1.4, U4.2 (A0)
/input1/B2_O: U4.18 (B0); also elsewhere on the board
/input1/B3: J1.6, U4.5 (A3)
/input1/B3_O: U4.15 (B3); also elsewhere on the board
/input1/F0: J2.7, U3.8 (A6)
/input1/F0_O: U3.12 (B6); also elsewhere on the board
/input1/F1: J2.8, U3.7 (A5)
/input1/F1_O: U3.13 (B5); also elsewhere on the board
/input1/F2: J2.9, U3.6 (A4)
/input1/F2_O: U3.14 (B4); also elsewhere on the board
/input1/F3: J2.10, U3.5 (A3)
/input1/F3_O: U3.15 (B3); also elsewhere on the board
/input1/G0: J1.7, U4.6 (A4)
/input1/G0_O: U4.14 (B4); also elsewhere on the board
/input1/G1: J1.8, U4.7 (A5)
/input1/G1_O: U4.13 (B5); also elsewhere on the board
/input1/G2: J1.9, U4.8 (A6)
/input1/G2_O: U4.12 (B6); also elsewhere on the board
/input1/G3: J1.10, U4.9 (A7)
/input1/G3_O: U4.11 (B7); also elsewhere on the board
/input1/HSYNC_O: U16.4; also elsewhere on the board
/input1/PCLK: U9.4; also elsewhere on the board
/input1/R0: J2.2, U3.4 (A2)
/input1/R0_O: U3.16 (B2); also elsewhere on the board
/input1/R1: J2.3, U3.3 (A1)
/input1/R1_O: U3.17 (B1); also elsewhere on the board
/input1/R2: J2.4, U3.2 (A0)
/input1/R2_O: U3.18 (B0); also elsewhere on the board
/input1/R3: J2.6, U3.9 (A7)
/input1/R3_O: U3.11 (B7); also elsewhere on the board
/input1/VOL+_O: U5.18 (B0); also elsewhere on the board
/input1/VOL-_O: U5.17 (B1); also elsewhere on the board
/input1/VSYNC_O: U16.6; also elsewhere on the board
GND: C2.2, C5.2, C6.1, C7.1, C8.1, C9.1, C14.2, C15.1, C16.1, D1.2, J1.5, J2.5, SW1.1, SW1.2, U3.10 (GND), U3.19 (CE), U4.10 (GND), U4.19 (CE), U5.5 (A3), U5.6 (A4), U5.8 (A6), U5.9 (A7), U5.10 (GND), U5.19 (CE), U6.7, U6.EP, U8.1, U8.2, U9.2, U16.2, W7.1, W8.1, W9.1, W10.1, W14.1; also elsewhere on the board
unnamed: R4.2, U6.3
unnamed: R7.2, SW1.3, U5.2 (A0), W5.1
unnamed: R8.2, SW1.4, U5.3 (A1), W6.1
unnamed: U5.4 (A2), W4.1
unnamed: U5.7 (A5), W3.1
unnamed: U6.6, U9.6
unnamed: U8.3, W2.1
unnamed: U9.1, W15.1
unnamed: U9.3, W13.1
unnamed: U16.1, W12.1
unnamed: U16.3, W11.1

Notes on the sheet:
CPS3 only

Schematic: fpga.sch, CPS2_digiAV

Parts:
C17, C18, C19, C20, C21, C22, C23, C25, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C50, C51, C53, C54, C55, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C99, C101: 0.1u; SM0603_Capa_libcms
C26, C49, C108: 10u; SM0603_Capa_libcms
C91, C92, C94, C96, C97, C98: 1u; SM0603_Capa_libcms
J3, J5, J6, J7: GS2
P1: JTAG_CONN; VASCH5x2
R1, R2: 2.2k; SM0603_Resistor_libcms
R6, R16, R17, R18, R21, R22: 10k; SM0603_Resistor_libcms
R19, R24: 4.7k; SM0603_Resistor_libcms
R20: 1k; SM0603_Resistor_libcms
R23: 25; SM0603_Resistor_libcms
U2: 10CL025YE144C8N; TQFP-144_thermal
U10: IS25LP016D-JBLE; SOIC-8_3.9x4.9mm_Pitch1.27mm_Handsoldering
U11: SRC4190; SSOP-28_5.3x10.2mm_Pitch0.65mm
U12, U14: TLV70012; SOT-23-5_Handsoldering
U13: TLV70025; SOT-23-5_Handsoldering

Connections:
/fpga1/ASDO: U2.6, U10.5 (SI)
/fpga1/BCKO: J3.2, U2.22, U11.25
/fpga1/DATA0: R23.1, U2.13
/fpga1/DCLK: U2.12, U10.6 (SCK)
/fpga1/HDMITX_HSYNC: U2.42; also elsewhere on the board
/fpga1/HDMITX_I2S_BCK: U2.33; also elsewhere on the board
/fpga1/HDMITX_I2S_DATA: U2.46; also elsewhere on the board
/fpga1/HDMITX_I2S_WS: U2.32; also elsewhere on the board
/fpga1/HDMITX_INT_N: U2.65; also elsewhere on the board
/fpga1/HDMITX_PCLK: U2.68; also elsewhere on the board
/fpga1/HDMITX_R0: U2.86; also elsewhere on the board
/fpga1/HDMITX_R1: U2.87; also elsewhere on the board
/fpga1/HDMITX_R2: U2.98; also elsewhere on the board
/fpga1/HDMITX_R3: U2.99; also elsewhere on the board
/fpga1/HDMITX_R4: U2.100; also elsewhere on the board
/fpga1/HDMITX_R5: U2.101; also elsewhere on the board
/fpga1/HDMITX_R6: U2.103; also elsewhere on the board
/fpga1/HDMITX_R7: U2.106; also elsewhere on the board
/fpga1/HDMITX_VSYNC: U2.39; also elsewhere on the board
/fpga1/I2S_BCK: J3.1, U11.5; also elsewhere on the board
/fpga1/I2S_DATA: J6.1, U11.4; also elsewhere on the board
/fpga1/I2S_WS: J5.1, U11.6; also elsewhere on the board
/fpga1/LGRP: J7.1, R6.1, U11.1
/fpga1/LRCKO: J5.2, U2.10, U11.24
/fpga1/MCLK_SI: U2.23, U11.2; also elsewhere on the board
/fpga1/PCLK_SI: U2.24; also elsewhere on the board
/fpga1/SCL: R1.2, U2.142; also elsewhere on the board
/fpga1/SDA: R2.2, U2.141; also elsewhere on the board
/fpga1/SDOUT: J6.2, U2.11, U11.23
/fpga1/TCK: P1.1, R20.2, U2.16
/fpga1/TDI: P1.9, R22.2, U2.15
/fpga1/TDO: P1.3, U2.20
/fpga1/TMS: P1.5, R21.2, U2.18
/fpga1/VCCA: C44.1, C46.1, C61.1, C64.1, C97.1, P1.4, R21.1, R22.1, U2.3, U2.35, U2.75, U2.96, U2.107, U13.5
/fpga1/VCCD_PLL: C43.1, C47.1, C60.1, C65.1, C98.1, U2.1, U2.37, U2.73, U2.109, U14.5
/fpga1/VCCINT: C19.1, C21.1, C39.1, C41.1, C42.1, C48.1, C49.1, C50.1, C51.1, C54.1, C58.1, C59.1, C66.1, C67.1, C68.1, C96.1, U2.5, U2.29, U2.34, U2.38, U2.45, U2.61, U2.70, U2.78, U2.84, U2.102, U2.116, U2.124, U2.134, U2.138, U12.5
/fpga1/nCSO: U2.8, U10.1 (CSn)
/hdmitx1/B0: U2.44; also elsewhere on the board
/hdmitx1/B1: U2.49; also elsewhere on the board
/hdmitx1/B2: U2.50; also elsewhere on the board
/hdmitx1/B3: U2.51; also elsewhere on the board
/hdmitx1/B4: U2.58; also elsewhere on the board
/hdmitx1/B5: U2.59; also elsewhere on the board
/hdmitx1/B6: U2.60; also elsewhere on the board
/hdmitx1/B7: U2.66; also elsewhere on the board
/hdmitx1/DE: U2.43; also elsewhere on the board
/hdmitx1/DVDD3V3: C17.1, C18.1, C20.1, C22.1, C23.1, C25.1, C26.1, C40.1, C45.1, C53.1, C55.2, C57.1, C62.1, C63.1, C91.1, C92.1, C94.1, C99.1, C101.1, C108.1, R1.1, R2.1, R6.2, R16.1, R17.2, R18.1, R19.2, R24.2, U2.17, U2.26, U2.40, U2.47, U2.56, U2.62, U2.81, U2.93, U2.117, U2.122, U2.130, U2.139, U10.8 (VCC), U11.7, U11.12, U11.13, U11.19, U11.22, U11.26, U11.27, U12.1, U12.3, U13.1, U13.3, U14.1, U14.3; also elsewhere on the board
/hdmitx1/G0: U2.67; also elsewhere on the board
/hdmitx1/G1: U2.69; also elsewhere on the board
/hdmitx1/G2: U2.71; also elsewhere on the board
/hdmitx1/G3: U2.72; also elsewhere on the board
/hdmitx1/G4: U2.76; also elsewhere on the board
/hdmitx1/G5: U2.77; also elsewhere on the board
/hdmitx1/G6: U2.83; also elsewhere on the board
/hdmitx1/G7: U2.85; also elsewhere on the board
/input1/B0_O: U2.128; also elsewhere on the board
/input1/B1_O: U2.127; also elsewhere on the board
/input1/B2_O: U2.126; also elsewhere on the board
/input1/B3_O: U2.129; also elsewhere on the board
/input1/F0_O: U2.121; also elsewhere on the board
/input1/F1_O: U2.120; also elsewhere on the board
/input1/F2_O: U2.115; also elsewhere on the board
/input1/F3_O: U2.114; also elsewhere on the board
/input1/G0_O: U2.132; also elsewhere on the board
/input1/G1_O: U2.133; also elsewhere on the board
/input1/G2_O: U2.135; also elsewhere on the board
/input1/G3_O: U2.137; also elsewhere on the board
/input1/HSYNC_O: U2.31; also elsewhere on the board
/input1/PCLK: U2.25; also elsewhere on the board
/input1/R0_O: U2.113; also elsewhere on the board
/input1/R1_O: U2.112; also elsewhere on the board
/input1/R2_O: U2.111; also elsewhere on the board
/input1/R3_O: U2.125; also elsewhere on the board
/input1/VOL+_O: U2.143; also elsewhere on the board
/input1/VOL-_O: U2.144; also elsewhere on the board
/input1/VSYNC_O: U2.28; also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C53.2, C54.2, C55.1, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C91.2, C92.2, C94.2, C96.2, C97.2, C98.2, C99.2, C101.2, C108.2, J7.2, P1.2, P1.10, R20.1, U2.2, U2.4, U2.19, U2.21, U2.27, U2.30, U2.36, U2.41, U2.48, U2.52, U2.53, U2.54, U2.55, U2.57, U2.63, U2.64, U2.74, U2.79, U2.82, U2.88, U2.89, U2.90, U2.91, U2.94, U2.95, U2.97, U2.104, U2.108, U2.110, U2.118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; also elsewhere on the board
unnamed: R16.2, U2.9
unnamed: R17.1, U2.14
unnamed: R18.2, U2.92
unnamed: R19.1, U10.7 (HOLDn)
unnamed: R23.2, U10.2 (SO)
unnamed: R24.1, U10.3 (WPn)

Notes on the sheet:
max. 200mA
max. 25mA
max. 20mA (VCCIO)
max. 100mA (VCCINT)
max. 30mA (VCCA)
max. 30mA (VCCD_PLL)
max. 68mA
CPS3 only

Board: 2 copper layers, 103.9 x 43.5 mm, 146 parts (74 on the bottom side), 130 nets.

## KiCad design pcb/pcb_v1.0/cps2_digiav.kicad_pcb

Schematic: cps2_digiav.sch

Parts:
C1, C3: 10u; SM0603_Capa_libcms
C2, C4: 1u; SM0603_Capa_libcms
U7: AP7361; SOT-223_Handsoldering
U8: TLV70033; SOT-23-5_Handsoldering

Connections:
/5V: C1.1, C2.1, U7.1, U8.1, U8.3; also elsewhere on the board
/A33VDD: C4.1, U8.5; also elsewhere on the board
/hdmitx1/DVDD3V3: C3.1, U7.3; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, U7.2, U8.2; also elsewhere on the board

Notes on the sheet:
max. 184mA drawn
1mA drawn
I2C pull-ups inside
max. 205mA drawn
max. 200mA
max. 500mA

Schematic: hdmitx.sch, CPS2_digiAV

Parts:
C10, C11, C12, C13, C110: 10u; SM0603_Capa_libcms
C69, C73, C74, C75, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86: 0.1u; SM0603_Capa_libcms
C87, C88, C89, C90: 1u; SM0603_Capa_libcms
D2, D3: RClamp0524P; SLP2510P8
F2: MF-FSMF020X-2; SM0603_Resistor_libcms
FB1, FB2, FB3, FB4: MPZ1608S221A; SM0603_Resistor_libcms
J4: HDMI_CONN; HDMI_CONN-10029449-111RLF; Part ID 10029449-111RLF
R3: 887; SM0603_Resistor_libcms
R41, R45, R46: 4.7k; SM0603_Resistor_libcms
U1: ADV7513; LQFP-64-1EP_10x10mm_Pitch0.5mm
U15, U16: TLV70018; SOT-23-5_Handsoldering

Connections:
/5V: F2.1; also elsewhere on the board
/A33VDD: C88.1, U16.1, U16.3; also elsewhere on the board
/fpga1/AUD_MCLK: U1.4 (MCLK); also elsewhere on the board
/fpga1/HDMITX_HSYNC: U1.64 (HSYNC); also elsewhere on the board
/fpga1/HDMITX_I2S_BCK: U1.9 (SCLK); also elsewhere on the board
/fpga1/HDMITX_I2S_DATA: U1.5 (I2S0); also elsewhere on the board
/fpga1/HDMITX_I2S_WS: U1.10 (LRCLK); also elsewhere on the board
/fpga1/HDMITX_INT_N: U1.28 (INT); also elsewhere on the board
/fpga1/HDMITX_PCLK: U1.53 (CLK); also elsewhere on the board
/fpga1/HDMITX_R0: U1.44 (DATA16); also elsewhere on the board
/fpga1/HDMITX_R1: U1.43 (DATA17); also elsewhere on the board
/fpga1/HDMITX_R2: U1.42 (DATA18); also elsewhere on the board
/fpga1/HDMITX_R3: U1.41 (DATA19); also elsewhere on the board
/fpga1/HDMITX_R4: U1.40 (DATA20); also elsewhere on the board
/fpga1/HDMITX_R5: U1.39 (DATA21); also elsewhere on the board
/fpga1/HDMITX_R6: U1.38 (DATA22); also elsewhere on the board
/fpga1/HDMITX_R7: U1.37 (DATA23); also elsewhere on the board
/fpga1/HDMITX_RESET_N: U1.22 (PD); also elsewhere on the board
/fpga1/HDMITX_VSYNC: U1.2 (VSYNC); also elsewhere on the board
/fpga1/SCL: U1.35 (SCL); also elsewhere on the board
/fpga1/SDA: U1.36 (SDA); also elsewhere on the board
/hdmitx1/5V_FUSED: F2.2, J4.18 (+5V), R45.1, R46.1
/hdmitx1/AVDD1V8: C85.1, C86.1, C90.1, C110.1, FB1.1, FB2.1, U16.5
/hdmitx1/B0: U1.62 (DATA0); also elsewhere on the board
/hdmitx1/B1: U1.61 (DATA1); also elsewhere on the board
/hdmitx1/B2: U1.60 (DATA2); also elsewhere on the board
/hdmitx1/B3: U1.59 (DATA3); also elsewhere on the board
/hdmitx1/B4: U1.58 (DATA4); also elsewhere on the board
/hdmitx1/B5: U1.57 (DATA5); also elsewhere on the board
/hdmitx1/B6: U1.56 (DATA6); also elsewhere on the board
/hdmitx1/B7: U1.55 (DATA7); also elsewhere on the board
/hdmitx1/DDCSCL: J4.15 (SCL), R46.2, U1.33 (DDCSCL)
/hdmitx1/DDCSDA: J4.16 (SDA), R45.2, U1.34 (DDCSDA)
/hdmitx1/DE: U1.63 (DE); also elsewhere on the board
/hdmitx1/DVDD1V8: C74.1, C89.1, FB3.2, U15.5
/hdmitx1/DVDD3V3: C75.1, C87.1, FB4.2, U15.1, U15.3; also elsewhere on the board
/hdmitx1/G0: U1.54 (DATA8); also elsewhere on the board
/hdmitx1/G1: U1.52 (DATA9); also elsewhere on the board
/hdmitx1/G2: U1.50 (DATA10); also elsewhere on the board
/hdmitx1/G3: U1.49 (DATA11); also elsewhere on the board
/hdmitx1/G4: U1.48 (DATA12); also elsewhere on the board
/hdmitx1/G5: U1.47 (DATA13); also elsewhere on the board
/hdmitx1/G6: U1.46 (DATA14); also elsewhere on the board
/hdmitx1/G7: U1.45 (DATA15); also elsewhere on the board
/hdmitx1/HPD: J4.19 (HPD), R41.1, U1.16 (HPD)
/hdmitx1/TX0+: D3.1, D3.10, J4.7 (TMDS_D0+), U1.21 (TX0+)
/hdmitx1/TX0-: D3.2, D3.9, J4.9 (TMDS_D0-), U1.20 (TX0-)
/hdmitx1/TX1+: D2.4, D2.7, J4.4 (TMDS_D1+), U1.24 (TX1+)
/hdmitx1/TX1-: D2.5, D2.6, J4.6 (TMDS_D1-), U1.23 (TX1-)
/hdmitx1/TX2+: D2.1, D2.10, J4.1 (TMDS_D2+), U1.27 (TX2+)
/hdmitx1/TX2-: D2.2, D2.9, J4.3 (TMDS_D2-), U1.26 (TX2-)
/hdmitx1/TXC+: D3.4, D3.7, J4.10 (TMDS_CLK+), U1.18 (TXC+)
/hdmitx1/TXC-: D3.5, D3.6, J4.12 (TMDS_CLK-), U1.17 (TXC-)
GND: C10.2, C11.2, C12.2, C13.2, C69.2, C73.2, C74.2, C75.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C110.2, D2.3, D3.3, J4.2 (TMDS_D2_GND), J4.5 (TMDS_D1_GND), J4.8 (TMDS_D0_GND), J4.11 (TMDS_CLK_GND), J4.17 (DDC_GND), R3.2, R41.2, U1.65 (PAD/GND), U15.2, U16.2; also elsewhere on the board
unnamed: C10.1, C77.1, C78.1, C80.1, C81.1, FB3.1, U1.1 (DVDD), U1.11 (DVDD), U1.31 (DVDD), U1.51 (DVDD)
unnamed: C11.1, C82.1, FB4.1, U1.29 (DVDD_3V)
unnamed: C12.1, C69.1, C73.1, FB2.2, U1.12 (PVDD), U1.13 (BGVDD)
unnamed: C13.1, C79.1, C83.1, C84.1, FB1.2, U1.15 (AVDD), U1.19 (AVDD), U1.25 (AVDD)
unnamed: R3.1, U1.14 (R_EXT)

Notes on the sheet:
max. 55mA
max. 200mA
max. 1mA (OVDD)
max. 1mA (AVCC33)
max. 55mA (AVCC18)
max. 127mA (DVDD18)

Parts:
C5: 47u; SM0603_Capa_libcms
C6, C7, C8, C9, C14, C15: 0.1u; SM0603_Capa_libcms
D1: SD05-7; SOD-323_Handsoldering
J1, J2: Conn_02x05; DIP-10_W7.62mm_LongPads
R4: 4.7k; SM0603_Resistor_libcms
U3, U4, U5: 74LVC245; TSSOP-20_4.4x6.5mm_Pitch0.65mm_Handsoldering
U6: SI5351C-B; QFN-20-1EP_4x4mm_Pitch0.5mm_Handsoldering
U9: SN74LVC3G17; SSOP-8_3x3mm_Pitch0.65mm
W1: 5V; SMD_PAD
W2: I2S_BCK; SMD_PAD
W3: I2S_WS; SMD_PAD
W4: I2S_DATA; SMD_PAD
W5: btn_vol+; SMD_PAD
W6: btn_vol-; SMD_PAD
W7, W8, W9, W10: GND; SMD_PAD
W11: HSYNC; SMD_PAD
W12: VSYNC; SMD_PAD
W13: PCLKx2; SMD_PAD

Connections:
/fpga1/CLK0: U6.13; also elsewhere on the board
/fpga1/I2S_BCK: U5.18 (B0); also elsewhere on the board
/fpga1/I2S_DATA: U5.16 (B2); also elsewhere on the board
/fpga1/I2S_WS: U5.17 (B1); also elsewhere on the board
/fpga1/SCL: U6.4; also elsewhere on the board
/fpga1/SDA: U6.5; also elsewhere on the board
/hdmitx1/DVDD3V3: C6.2, C7.2, C8.2, C9.2, C14.1, C15.2, R4.1, U3.1 (A->B), U3.20 (VCC), U4.1 (A->B), U4.20 (VCC), U5.1 (A->B), U5.20 (VCC), U6.10, U6.11, U6.14, U6.18, U6.20, U9.8 (Vcc); also elsewhere on the board
/input1/5V: C5.1, D1.1, W1.1
/input1/B0_O: U4.11 (B7); also elsewhere on the board
/input1/B1_O: U4.12 (B6); also elsewhere on the board
/input1/B2_O: U4.13 (B5); also elsewhere on the board
/input1/B3_O: U4.14 (B4); also elsewhere on the board
/input1/F0_O: U3.15 (B3); also elsewhere on the board
/input1/F1_O: U3.16 (B2); also elsewhere on the board
/input1/F2_O: U3.17 (B1); also elsewhere on the board
/input1/F3_O: U3.18 (B0); also elsewhere on the board
/input1/G0_O: U4.15 (B3); also elsewhere on the board
/input1/G1_O: U4.16 (B2); also elsewhere on the board
/input1/G2_O: U4.17 (B1); also elsewhere on the board
/input1/G3_O: U4.18 (B0); also elsewhere on the board
/input1/HSYNC_O: U9.7 (1Y); also elsewhere on the board
/input1/PCLKx2: U6.6, U9.2 (3Y); also elsewhere on the board
/input1/R0_O: U3.11 (B7); also elsewhere on the board
/input1/R1_O: U3.12 (B6); also elsewhere on the board
/input1/R2_O: U3.13 (B5); also elsewhere on the board
/input1/R3_O: U3.14 (B4); also elsewhere on the board
/input1/VOL+_O: U5.15 (B3); also elsewhere on the board
/input1/VOL-_O: U5.14 (B4); also elsewhere on the board
/input1/VSYNC_O: U9.5 (2Y); also elsewhere on the board
GND: C5.2, C6.1, C7.1, C8.1, C9.1, C14.2, C15.1, D1.2, J1.5, J2.5, U3.10 (GND), U3.19 (CE), U4.10 (GND), U4.19 (CE), U5.10 (GND), U5.19 (CE), U6.7, U6.EP, U9.4 (GND), W7.1, W8.1, W9.1, W10.1; also elsewhere on the board
unnamed: J1.2, U4.9 (A7)
unnamed: J1.3, U4.8 (A6)
unnamed: J1.4, U4.7 (A5)
unnamed: J1.6, U4.6 (A4)
unnamed: J1.7, U4.5 (A3)
unnamed: J1.8, U4.4 (A2)
unnamed: J1.9, U4.3 (A1)
unnamed: J1.10, U4.2 (A0)
unnamed: J2.2, U3.9 (A7)
unnamed: J2.3, U3.8 (A6)
unnamed: J2.4, U3.7 (A5)
unnamed: J2.6, U3.6 (A4)
unnamed: J2.7, U3.5 (A3)
unnamed: J2.8, U3.4 (A2)
unnamed: J2.9, U3.3 (A1)
unnamed: J2.10, U3.2 (A0)
unnamed: R4.2, U6.3
unnamed: U5.2 (A0), W2.1
unnamed: U5.3 (A1), W3.1
unnamed: U5.4 (A2), W4.1
unnamed: U5.5 (A3), W5.1
unnamed: U5.6 (A4), W6.1
unnamed: U9.1 (1A), W11.1
unnamed: U9.3 (2A), W12.1
unnamed: U9.6 (3A), W13.1
