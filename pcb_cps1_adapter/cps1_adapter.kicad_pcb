# Repository marqs85/cps2_digiav (continued)

## KiCad design pcb/pcb_v1.0/cps2_digiav.kicad_pcb (continued)

Parts:
C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C50, C51, C53, C54, C55, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C99, C101: 0.1u; SM0603_Capa_libcms
C49, C108: 10u; SM0603_Capa_libcms
C52, C91, C92, C94, C96, C97, C98: 1u; SM0603_Capa_libcms
P1: JTAG_CONN; VASCH5x2
R1, R2: 2.2k; SM0603_Resistor_libcms
R16, R17, R18, R21, R22: 10k; SM0603_Resistor_libcms
R19, R24: 4.7k; SM0603_Resistor_libcms
R20: 1k; SM0603_Resistor_libcms
R23: 25; SM0603_Resistor_libcms
U2: EP4CE15E22; TQFP-144_thermal
U10: S25FL116K; SOIC-8_3.9x4.9mm_Pitch1.27mm_Handsoldering
U12, U14: TLV70012; SOT-23-5_Handsoldering
U13: TLV70025; SOT-23-5_Handsoldering

Connections:
/fpga1/ASDO: U2.6 (DATA1), U10.5 (SI)
/fpga1/AUD_MCLK: U2.100 (IO100); also elsewhere on the board
/fpga1/CLK0: U2.88 (CLK7); also elsewhere on the board
/fpga1/DATA0: R23.1, U2.13 (DATA0)
/fpga1/DCLK: U2.12 (DCLK), U10.6 (SCK)
/fpga1/HDMITX_HSYNC: U2.103 (IO103); also elsewhere on the board
/fpga1/HDMITX_I2S_BCK: U2.87 (IO87); also elsewhere on the board
/fpga1/HDMITX_I2S_DATA: U2.99 (IO99); also elsewhere on the board
/fpga1/HDMITX_I2S_WS: U2.98 (IO98); also elsewhere on the board
/fpga1/HDMITX_INT_N: U2.86 (IO86); also elsewhere on the board
/fpga1/HDMITX_PCLK: U2.120 (IO120); also elsewhere on the board
/fpga1/HDMITX_R0: U2.137 (IO137); also elsewhere on the board
/fpga1/HDMITX_R1: U2.141 (IO141); also elsewhere on the board
/fpga1/HDMITX_R2: U2.142 (IO142); also elsewhere on the board
/fpga1/HDMITX_R3: U2.143 (IO143); also elsewhere on the board
/fpga1/HDMITX_R4: U2.144 (IO144); also elsewhere on the board
/fpga1/HDMITX_R5: U2.7 (IO7); also elsewhere on the board
/fpga1/HDMITX_R6: U2.10 (IO10); also elsewhere on the board
/fpga1/HDMITX_R7: U2.11 (IO11); also elsewhere on the board
/fpga1/HDMITX_RESET_N: U2.85 (IO85); also elsewhere on the board
/fpga1/HDMITX_VSYNC: U2.101 (IO101); also elsewhere on the board
/fpga1/I2S_BCK: U2.55 (CLK12); also elsewhere on the board
/fpga1/I2S_DATA: U2.59 (IO59); also elsewhere on the board
/fpga1/I2S_WS: U2.58 (IO58); also elsewhere on the board
/fpga1/SCL: R1.2, U2.31 (IO31); also elsewhere on the board
/fpga1/SDA: R2.2, U2.30 (IO30); also elsewhere on the board
/fpga1/TCK: P1.1, R20.2, U2.16 (TCK)
/fpga1/TDI: P1.9, R22.2, U2.15 (TDI)
/fpga1/TDO: P1.3, U2.20 (TDO)
/fpga1/TMS: P1.5, R21.2, U2.18 (TMS)
/fpga1/VCCA: C44.1, C46.1, C61.1, C64.1, C97.1, P1.4, R21.1, R22.1, U2.3 (VCCA3), U2.35 (VCCA1), U2.75 (VCCA4), U2.96 (MSEL1), U2.107 (VCCA2), U13.5 (OUT)
/fpga1/VCCD_PLL: C43.1, C47.1, C60.1, C65.1, C98.1, U2.1 (VCCD_PLL3), U2.37 (VCCD_PLL1), U2.73 (VCCD_PLL4), U2.109 (VCCD_PLL2), U14.5 (OUT)
/fpga1/VCCINT: C39.1, C41.1, C42.1, C48.1, C49.1, C50.1, C51.1, C54.1, C58.1, C59.1, C66.1, C67.1, C68.1, C96.1, U2.5 (VCCINT), U2.29 (VCCINT), U2.34 (VCCINT), U2.38 (VCCINT), U2.45 (VCCINT), U2.70 (VCCINT), U2.78 (VCCINT), U2.84 (VCCINT), U2.102 (VCCINT), U2.116 (VCCINT), U2.124 (VCCINT), U2.138 (VCCINT), U12.5 (OUT)
/fpga1/nCSO: U2.8 (FLASH_nCE), U10.1 (CSn)
/hdmitx1/B0: U2.105 (IO105); also elsewhere on the board
/hdmitx1/B1: U2.106 (IO106); also elsewhere on the board
/hdmitx1/B2: U2.110 (IO110); also elsewhere on the board
/hdmitx1/B3: U2.111 (IO111); also elsewhere on the board
/hdmitx1/B4: U2.112 (IO112); also elsewhere on the board
/hdmitx1/B5: U2.113 (IO113); also elsewhere on the board
/hdmitx1/B6: U2.114 (IO114); also elsewhere on the board
/hdmitx1/B7: U2.115 (IO115); also elsewhere on the board
/hdmitx1/DE: U2.104 (IO104); also elsewhere on the board
/hdmitx1/DVDD3V3: C40.1, C45.1, C52.1, C53.1, C55.2, C57.1, C62.1, C63.1, C91.1, C92.1, C94.1, C99.1, C101.1, C108.1, R1.1, R2.1, R16.1, R17.2, R18.1, R19.2, R24.2, U2.17 (VCCIO1), U2.26 (VCCIO2), U2.40 (VCCIO3), U2.47 (VCCIO3), U2.56 (VCCIO4), U2.62 (VCCIO4), U2.81 (VCCIO5), U2.93 (VCCIO6), U2.117 (VCCIO7), U2.122 (VCCIO7), U2.130 (VCCIO8), U2.139 (VCCIO8), U10.8 (VCC), U12.1 (IN), U12.3 (~EN~), U13.1 (IN), U13.3 (~EN~), U14.1 (IN), U14.3 (~EN~); also elsewhere on the board
/hdmitx1/G0: U2.119 (IO119); also elsewhere on the board
/hdmitx1/G1: U2.121 (IO121); also elsewhere on the board
/hdmitx1/G2: U2.125 (IO125); also elsewhere on the board
/hdmitx1/G3: U2.132 (IO132); also elsewhere on the board
/hdmitx1/G4: U2.133 (IO133); also elsewhere on the board
/hdmitx1/G5: U2.134 (IO134); also elsewhere on the board
/hdmitx1/G6: U2.135 (IO135); also elsewhere on the board
/hdmitx1/G7: U2.136 (IO136); also elsewhere on the board
/input1/B0_O: U2.72 (IO72); also elsewhere on the board
/input1/B1_O: U2.71 (IO71); also elsewhere on the board
/input1/B2_O: U2.69 (IO69); also elsewhere on the board
/input1/B3_O: U2.68 (IO68); also elsewhere on the board
/input1/F0_O: U2.44 (IO44); also elsewhere on the board
/input1/F1_O: U2.43 (IO43); also elsewhere on the board
/input1/F2_O: U2.42 (IO42); also elsewhere on the board
/input1/F3_O: U2.39 (IO39); also elsewhere on the board
/input1/G0_O: U2.67 (IO67); also elsewhere on the board
/input1/G1_O: U2.66 (IO66); also elsewhere on the board
/input1/G2_O: U2.65 (IO65); also elsewhere on the board
/input1/G3_O: U2.64 (IO64); also elsewhere on the board
/input1/HSYNC_O: U2.91 (CLK4); also elsewhere on the board
/input1/PCLKx2: U2.89 (CLK6); also elsewhere on the board
/input1/R0_O: U2.51 (IO51); also elsewhere on the board
/input1/R1_O: U2.50 (IO50); also elsewhere on the board
/input1/R2_O: U2.49 (IO49); also elsewhere on the board
/input1/R3_O: U2.46 (IO46); also elsewhere on the board
/input1/VOL+_O: U2.60 (IO60); also elsewhere on the board
/input1/VOL-_O: U2.61 (IO61); also elsewhere on the board
/input1/VSYNC_O: U2.90 (CLK5); also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.1, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C91.2, C92.2, C94.2, C96.2, C97.2, C98.2, C99.2, C101.2, C108.2, P1.2, P1.10, R20.1, U2.2 (GNDA3), U2.4 (GND), U2.19 (GND), U2.21 (nCE), U2.22 (GND), U2.23 (CLK1), U2.24 (CLK2), U2.25 (CLK3), U2.27 (GND), U2.36 (GNDA1), U2.41 (GND), U2.48 (GND), U2.52 (CLK15), U2.53 (CLK14), U2.54 (CLK13), U2.57 (GND), U2.63 (GND), U2.74 (GNDA4), U2.79 (GND), U2.82 (GND), U2.94 (MSEL0), U2.95 (GND), U2.97 (MSEL2), U2.108 (GNDA2), U2.118 (GND), U2.123 (GND), U2.126 (CLK8), U2.127 (CLK9), U2.128 (CLK10), U2.129 (CLK11), U2.131 (GND), U2.140 (GND), U10.4 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND); also elsewhere on the board
unnamed: R16.2, U2.9 (nSTATUS)
unnamed: R17.1, U2.14 (nCONFIG)
unnamed: R18.2, U2.92 (CONF_DONE)
unnamed: R19.1, U10.7 (HOLDn)
unnamed: R23.2, U10.2 (SO)
unnamed: R24.1, U10.3 (WPn)

Notes on the sheet:
max. 200mA
max. 25mA
max. 20mA (VCCIO)
max. 100mA (VCCINT)
max. 30mA (VCCA)
max. 30mA (VCCD_PLL)

Board: 2 copper layers, 103.4 x 48.7 mm, 128 parts (85 on the bottom side), 127 nets.

## Code that names these connections

File cps2_digiav.qsf:

# -------------------------------------------------------------------------- #
#
# Copyright (C) 2016  Intel Corporation. All rights reserved.
# Your use of Intel Corporation's design tools, logic functions 
# and other software and tools, and its AMPP partner logic 
# functions, and any output files from any of the foregoing 
# (including device programming or simulation files), and any 
# associated documentation or information are expressly subject 
# to the terms and conditions of the Intel Program License 
# Subscription Agreement, the Intel Quartus Prime License Agreement,
# the Intel MegaCore Function License Agreement, or other 
# applicable license agreement, including, without limitation, 
# that your use is for the sole purpose of programming logic 
# devices manufactured by Intel and sold by Intel or its 
# authorized distributors.  Please refer to the applicable 
# agreement for further details.
#
# -------------------------------------------------------------------------- #
#
# Quartus Prime
# Version 16.1.0 Build 196 10/24/2016 SJ Lite Edition
# Date created = 23:25:51  November 29, 2016
#
# -------------------------------------------------------------------------- #
#
# Notes:
#
# 1) The default values for assignments are stored in the file:
#		cps2_digiav_assignment_defaults.qdf
#    If this file doesn't exist, see file:
#		assignment_defaults.qdf
#
# 2) Altera recommends that you do not modify this file. This
#    file is updated automatically by the Quartus Prime software
#    and any changes you make may be lost or overwritten.
#
# -------------------------------------------------------------------------- #

set_global_assignment -name FAMILY "Cyclone 10 LP"
set_global_assignment -name DEVICE 10CL025YE144C8G
set_global_assignment -name TOP_LEVEL_ENTITY cps2_digiav
set_global_assignment -name ORIGINAL_QUARTUS_VERSION 16.1.0
set_global_assignment -name PROJECT_CREATION_TIME_DATE "23:25:51  NOVEMBER 29, 2016"
set_global_assignment -name LAST_QUARTUS_VERSION "19.1.0 Lite Edition"
set_global_assignment -name PROJECT_OUTPUT_DIRECTORY output_files
set_global_assignment -name MIN_CORE_JUNCTION_TEMP 0
set_global_assignment -name MAX_CORE_JUNCTION_TEMP 85
set_global_assignment -name DEVICE_FILTER_PACKAGE TQFP
set_global_assignment -name DEVICE_FILTER_PIN_COUNT 144
set_global_assignment -name ERROR_CHECK_FREQUENCY_DIVISOR 1
set_global_assignment -name POWER_PRESET_COOLING_SOLUTION "NO HEAT SINK WITH STILL AIR"
set_global_assignment -name POWER_BOARD_THERMAL_MODEL "NONE (CONSERVATIVE)"
set_global_assignment -name TIMING_ANALYZER_MULTICORNER_ANALYSIS ON
set_global_assignment -name SMART_RECOMPILE ON
set_global_assignment -name VERILOG_INPUT_VERSION SYSTEMVERILOG_2005
set_global_assignment -name VERILOG_SHOW_LMF_MAPPING_MESSAGES OFF
set_global_assignment -name ENABLE_OCT_DONE OFF
set_global_assignment -name ENABLE_CONFIGURATION_PINS OFF
set_global_assignment -name ENABLE_BOOT_SEL_PIN OFF
set_global_assignment -name STRATIXV_CONFIGURATION_SCHEME "PASSIVE SERIAL"
set_global_assignment -name USE_CONFIGURATION_DEVICE ON
set_global_assignment -name CYCLONEIII_CONFIGURATION_DEVICE EPCS16
set_global_assignment -name CRC_ERROR_OPEN_DRAIN OFF
set_global_assignment -name STRATIX_DEVICE_IO_STANDARD "3.3-V LVTTL"
set_global_assignment -name OUTPUT_IO_TIMING_NEAR_END_VMEAS "HALF VCCIO" -rise
set_global_assignment -name OUTPUT_IO_TIMING_NEAR_END_VMEAS "HALF VCCIO" -fall
set_global_assignment -name OUTPUT_IO_TIMING_FAR_END_VMEAS "HALF SIGNAL SWING" -rise
set_global_assignment -name OUTPUT_IO_TIMING_FAR_END_VMEAS "HALF SIGNAL SWING" -fall
set_global_assignment -name PARTITION_NETLIST_TYPE SOURCE -section_id Top
set_global_assignment -name PARTITION_FITTER_PRESERVATION_LEVEL PLACEMENT_AND_ROUTING -section_id Top
set_global_assignment -name PARTITION_COLOR 16764057 -section_id Top
set_global_assignment -name SEARCH_PATH rtl
set_location_assignment PIN_144 -to BTN_volminus
set_location_assignment PIN_101 -to HDMI_TX_RD[5]
set_location_assignment PIN_103 -to HDMI_TX_RD[6]
set_location_assignment PIN_106 -to HDMI_TX_RD[7]
set_location_assignment PIN_100 -to HDMI_TX_RD[4]
set_location_assignment PIN_99 -to HDMI_TX_RD[3]
set_location_assignment PIN_98 -to HDMI_TX_RD[2]
set_location_assignment PIN_87 -to HDMI_TX_RD[1]
set_location_assignment PIN_86 -to HDMI_TX_RD[0]
set_location_assignment PIN_85 -to HDMI_TX_GD[7]
set_location_assignment PIN_83 -to HDMI_TX_GD[6]
set_location_assignment PIN_77 -to HDMI_TX_GD[5]
set_location_assignment PIN_76 -to HDMI_TX_GD[4]
set_location_assignment PIN_72 -to HDMI_TX_GD[3]
set_location_assignment PIN_71 -to HDMI_TX_GD[2]
set_location_assignment PIN_69 -to HDMI_TX_GD[1]
set_location_assignment PIN_67 -to HDMI_TX_GD[0]
set_location_assignment PIN_60 -to HDMI_TX_BD[6]
set_location_assignment PIN_59 -to HDMI_TX_BD[5]
set_location_assignment PIN_68 -to HDMI_TX_PCLK
set_location_assignment PIN_58 -to HDMI_TX_BD[4]
set_location_assignment PIN_51 -to HDMI_TX_BD[3]
set_location_assignment PIN_50 -to HDMI_TX_BD[2]
set_location_assignment PIN_49 -to HDMI_TX_BD[1]
set_location_assignment PIN_44 -to HDMI_TX_BD[0]
set_location_assignment PIN_43 -to HDMI_TX_DE
set_location_assignment PIN_42 -to HDMI_TX_HS
set_location_assignment PIN_39 -to HDMI_TX_VS
set_location_assignment PIN_46 -to HDMI_TX_I2S_DATA
set_location_assignment PIN_32 -to HDMI_TX_I2S_WS
set_location_assignment PIN_33 -to HDMI_TX_I2S_BCK
set_location_assignment PIN_65 -to HDMI_TX_INT_N
set_location_assignment PIN_129 -to B_in[3]
set_location_assignment PIN_126 -to B_in[2]
set_location_assignment PIN_127 -to B_in[1]
set_location_assignment PIN_128 -to B_in[0]
set_location_assignment PIN_143 -to BTN_volplus
set_location_assignment PIN_11 -to I2S_DATA
set_location_assignment PIN_10 -to I2S_WS
set_location_assignment PIN_22 -to I2S_BCK
set_location_assignment PIN_31 -to HSYNC_in
set_location_assignment PIN_28 -to VSYNC_in
set_location_assignment PIN_25 -to PCLK2x_in
set_location_assignment PIN_137 -to G_in[3]
set_location_assignment PIN_135 -to G_in[2]
set_location_assignment PIN_133 -to G_in[1]
set_location_assignment PIN_132 -to G_in[0]
set_location_assignment PIN_125 -to R_in[3]
set_location_assignment PIN_111 -to R_in[2]
set_location_assignment PIN_112 -to R_in[1]
set_location_assignment PIN_113 -to R_in[0]
set_location_assignment PIN_142 -to scl
set_location_assignment PIN_141 -to sda
set_location_assignment PIN_114 -to F_in[3]
set_location_assignment PIN_115 -to F_in[2]
set_location_assignment PIN_120 -to F_in[1]
set_location_assignment PIN_121 -to F_in[0]
set_location_assignment PIN_66 -to HDMI_TX_BD[7]
set_global_assignment -name CYCLONEII_RESERVE_NCEO_AFTER_CONFIGURATION "USE AS REGULAR IO"
set_global_assignment -name RESERVE_DATA0_AFTER_CONFIGURATION "USE AS REGULAR IO"
set_global_assignment -name RESERVE_DATA1_AFTER_CONFIGURATION "USE AS REGULAR IO"
set_global_assignment -name RESERVE_FLASH_NCE_AFTER_CONFIGURATION "USE AS REGULAR IO"
set_global_assignment -name RESERVE_DCLK_AFTER_CONFIGURATION "USE AS REGULAR IO"
set_global_assignment -name ENABLE_SIGNALTAP OFF
set_global_assignment -name USE_SIGNALTAP_FILE output_files/cps2.stp
set_global_assignment -name DEVICE_FILTER_SPEED_GRADE 8
set_global_assignment -name ENABLE_LOGIC_ANALYZER_INTERFACE OFF
set_location_assignment PIN_23 -to MCLK_SI
set_location_assignment PIN_24 -to PCLK_SI

set_global_assignment -name QIP_FILE sys/synthesis/sys.qip
set_global_assignment -name QIP_FILE software/sys_controller/mem_init/meminit.qip
set_global_assignment -name SDC_FILE cps2_digiav.sdc
set_global_assignment -name QIP_FILE rtl/linebuf.qip
set_global_assignment -name VERILOG_FILE rtl/cps2_frontend.v
set_global_assignment -name VERILOG_FILE rtl/scanconverter.v
set_global_assignment -name VERILOG_FILE rtl/btn_debounce.v
set_global_assignment -name VERILOG_FILE rtl/i2s_upsampler_2x.v
set_global_assignment -name VERILOG_FILE rtl/i2s_upsampler_asrc.v
set_global_assignment -name VERILOG_FILE rtl/i2s_tx_asrc.v
set_global_assignment -name VERILOG_FILE rtl/i2s_rx_asrc.v
set_global_assignment -name VERILOG_FILE rtl/cps2_digiav.v
set_global_assignment -name QIP_FILE rtl/pll_i2s.qip
set_global_assignment -name SIGNALTAP_FILE output_files/stp1.stp
set_global_assignment -name QIP_FILE rtl/pll_pclk.qip
set_global_assignment -name QIP_FILE rtl/fir_2ch_audio.qip
set_global_assignment -name SIP_FILE rtl/fir_2ch_audio.sip
set_global_assignment -name OPTIMIZATION_MODE "AGGRESSIVE PERFORMANCE"
set_global_assignment -name SEED 1
set_instance_assignment -name PARTITION_HIERARCHY root_partition -to | -section_id Top

File board/toaplan2/cps2_digiav.qsf (part):

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set_location_assignment PIN_33 -to HDMI_TX_I2S_BCK
set_location_assignment PIN_65 -to HDMI_TX_INT_N
set_location_assignment PIN_143 -to BTN_volplus
set_location_assignment PIN_11 -to YM_SO
set_location_assignment PIN_10 -to YM_SH1
set_location_assignment PIN_22 -to YM_o1
set_location_assignment PIN_31 -to CSYNC_in
set_location_assignment PIN_28 -to WM_SO
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set_global_assignment -name DEVICE_FILTER_SPEED_GRADE 8
set_global_assignment -name ENABLE_LOGIC_ANALYZER_INTERFACE OFF
set_global_assignment -name INI_VARS "FIOMGR_ENABLE_SPI_TIMING=ON"
set_location_assignment PIN_23 -to MCLK_SI
set_location_assignment PIN_24 -to PCLK_SI
set_instance_assignment -name FAST_OUTPUT_REGISTER ON -to HDMI_TX_RD
set_instance_assignment -name FAST_OUTPUT_REGISTER ON -to HDMI_TX_GD
set_instance_assignment -name FAST_OUTPUT_REGISTER ON -to HDMI_TX_BD
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
## Commit log

2017-01-07 Add missing files
2017-04-10 line5x testing
2017-04-17 Fix 640x480 parameters.
2017-04-28 fix audio and fade
2017-08-28 Prepare for first public release
    * integrate new sync processing code from ossc
    * add PCB files
2017-08-31 First official release (v0.50).
2017-12-18 Moved ICs to top, made to fit ontop of CPS2 DIPs
2017-12-19 Added ADV7513
2017-12-19 update lib path
2017-12-21 Finished power section of ADV7531
2017-12-25 initial layout of ADV7513
2017-12-28 Added Si5351C
2017-12-30 Reordered inputs, improved clock layout
2018-01-30 Final changes before pull req
2018-02-02 Removing auto-generated files
2018-02-02 update to 10CL025YE144C8G FPGA
2018-02-02 This is a combination of 10 commits.
    Moved ICs to top, made to fit ontop of CPS2 DIPs
    Added ADV7513
    update lib path
    Finished power section of ADV7531
    initial layout of ADV7513
    Added Si5351C
2018-02-02 fix schematic and library linkage issues
2018-02-02 prepare working space for Rev 2
    Rename PCB folder, remove files referring to Rev 1 and update README.
2018-02-15 finalize schematic and do initial placement on PCB
2018-03-28 pcb: signal routing mostly done
2018-04-23 finalize rev. 2.0 pcb
2018-06-18 update RTL for Rev2
2018-06-18 update SW for Rev2
2018-06-18 add Rev2 BOM
2018-07-06 fix X/Y screen position
2018-07-06 use CPS2 voldown button for vertical adjustment
2018-08-05 fix scanlines and add bitstream files
2018-09-23 some cleanup
2019-01-06 integrate updates from cps3 branch
2019-01-06 update documentation to match v2.1 PCB
2019-01-26 audio ASRC implementation
2019-02-07 fix scanlines and FIR coefficients
2019-03-11 port audio ASRC implementation from rev2 branch
2019-04-15 fix reset sensitivity and update instructions
2019-06-12 fix random startup problem
2019-06-12 fix audio code mismatch and update instructions
2019-06-22 clarify installation instructions
2019-09-26 fix outdated BOM
2020-03-16 update quartus version
2020-03-21 update drivers and code to enable resolution switching
2020-03-30 optimize performance
2020-04-08 change input data sampling position
2020-04-08 reorganize repo hierarchy
    * simplifies porting of the project to other platforms
2020-04-08 integrate cps1 branch under new hierarchy
2020-04-09 integrate cps3 branch under new hierarchy
2020-04-09 update READMEs
2020-04-13 toaplan2: add preliminary support
2020-04-13 cps1: misc improvements
    * fix ADPCM audio
    * add 1280x1024 and 1600x1200 output modes
2020-04-15 sw_common: reorganize HDMI VIC/PR definitions
2020-04-15 rtl_common: add common i2s_rx_asrc verilog and fix warnings
2020-04-15 rtl/sw/ip_common: change source identification
    Use VCLK cycles as part of board/mode identification
2020-04-15 cps2: misc improvements
    * fix 240p audio
    * increase button debounce time
    * add 1280x1024 and 1600x1200 output modes
2020-04-16 toaplan2: rtl cleanup
2020-04-17 toaplan2: set better balance between OPM and ADPCM audio
2020-04-17 toaplan2: add documentation
2020-04-18 toaplan2: add PLL parameters for boards with standard sync
2020-04-18 cps1: fix 240p audio
2020-04-18 cps3: add 1280x1024 and 1600x1200 output modes
2020-10-03 cps2: integrate OSD functionality
2020-10-03 cps2: update README
2020-10-07 cps2: add scanline options
2020-11-09 update epcq_controller to epcq_controller2
2021-04-15 update IP versions and enable bitstream compression
2021-04-15 add support for Neo Geo
2021-04-18 neogeo: add documentation
2021-05-15 neogeo: fix reversed stereo and improve darkbit handling
2021-10-21 fix supported CPS1 revision info
2023-08-28 neogeo: add support for AES and DFO
2023-10-19 update instructions
    * add note about CPS3 syncs
    * add info about alternative button arrangements
2023-10-27 neogeo: fix AES compatibility
2023-10-29 neogeo: add AES instructions and ADC adapter files
2024-02-18 update CPS1 adapter with CPS 1.5 Multi support
2024-02-19 update CPS1 instructions
2024-02-19 update Neogeo instructions with AES3-6 details
2024-03-08 cps1: add fw support for CPS 1.5 Multi
2025-08-27 integrate ibex
2025-08-27 update BSP files
2025-08-27 remove non-essetial generated files
2025-09-19 cps2: neogeo: update fw to 0.94
2026-01-08 cps1: cps3: toaplan2: update to Quartus 24.1
2026-01-10 cps1: cps3: toaplan2: update fw to 0.94
2026-03-21 add missing flash sw files
2026-03-21 neogeo: add instructions for CDM install
